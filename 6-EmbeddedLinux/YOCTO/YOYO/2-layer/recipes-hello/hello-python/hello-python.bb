SUMMARY = "A simple Hello World Python script"
LICENSE = "CLOSED"

do_configure () {
    bbwarn "do_configure";
}
do_compile () {
    bbwarn "do_compile";
}
do_install () {
    bbwarn "do_install";
}